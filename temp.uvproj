# Keil uVision project temp.uvproj, settings and files
target temp (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: temp +hex
  c flags: Optim=1
  c include: .\lib\inc;.\user;.\SYSTEM;.\pixelC_hardware;.\Moduel;.\pixelC_hardware\pixelC_HW_SDcard_FATFS0.09a;.\SOLGUI;.\SOLGUI\Font
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./user/: main.c stm32f10x_it.c
  group pixelC_Hardware
    ./pixelC_hardware/: pixelC_HW_flagLight.c pixelC_HW_Key.c pixelC_HW_Port.c pixelC_HW_SDcard.c pixelC_HW_OLED.c pixelC_HW_24C02.c
  group SOLGUI
    ./SOLGUI/: SOLGUI_Hardware.c SOLGUI_Common.c SOLGUI_Printf.c SOLGUI_GBasic.c SOLGUI_Picture.c SOLGUI_Menu.c SOLGUI_Widget.c
    ./SOLGUI/Font/: Font4x6_ASCII.c Font6x8_ASCII.c Font8x8_ASCII.c Font8x10_ASCII.c
  group Module
    ./Moduel/: Badapple_Player.c
  group system
    ./SYSTEM/: system.c malloc.c delay.c I2C.c SPI.c
  group FATFS
    ./pixelC_hardware/pixelC_HW_SDcard_FATFS0.09a/: diskio.c ff.c
  group lib
    ./lib/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group start
    ./start/: cortexm3_macro.s stm32f10x_vector.s
